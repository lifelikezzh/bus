# Keil uVision project bus.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: bus +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h oled.c oled.h dht11.c dht11.h ds1302.c ds1302.h xpt2046.c xpt2046.h key.c key.h interrupt.c interrupt.h oledfont.h
